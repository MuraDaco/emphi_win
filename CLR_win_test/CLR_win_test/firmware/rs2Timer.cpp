/*

   MODULE DESCRIPTION:  

   AUTHOR:  Marco Ing. Dau		 																									

   ****************************************************************************************************************************************************
   * SVN-keywords: fields managed by SVN - DO NOT MODIFY 
   *
   *	USER who run commit:    $Author: Administrator $																										
   *	REVISION NUMBER:        $Revision: 344 $																											
   *	LAST DATE REVISION:     $Date: 2016-03-01 17:27:34 +0100 (mar, 01 mar 2016) $															
   *	LOCATION FILE:          $HeadURL: file:///C:/Users/Administrator/Documents/SVN/Repository/fw2/15101-emphil/work/rs2Timer.c $			
   *																																						
   ****************************************************************************************************************************************************

 */


#define	_TIMER_C

#include "platform.h"


// ----------------------------------------------------------------------------
// SECTION - SYSTEM INCLUDE
// ----------------------------------------------------------------------------

// ----------------------------------------------------------------------------
// SECTION - PROJECT INCLUDE (Dependecies)
#include "rs2TimerGlo.h"


// direct dependecies: none

//	reverse dependecies: see header file

// ----------------------------------------------------------------------------

//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
// SECTION - CONSTANT DEFINITION


// SECTION END
//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++

//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
// SECTION - VARIABLE DEFINITION

// SECTION END
//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++

//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
// SECTION - ARRAY DEFINITION

// SECTION END
//	++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++

//	****************************************************************************
// SECTION - CONTROL FUNCTION DEFINITION

// SECTION END
//	****************************************************************************

//	****************************************************************************
// SECTION - EVENT FUNCTION DEFINITION

// SECTION END
//	****************************************************************************


//	****************************************************************************
// SECTION - LIBRTARY FUNCTION DEFINITION

// SECTION END
//	****************************************************************************




//	****************************************************************************
//	****************************************************************************
void InitTimer (void)
{
   char i;
   
   for(i=0;i<TMR_NUMBER;i++)
   {
      Timer[i] = 0;
   }
   // TmrSecond init
   TmrSecond    = 1000;
   
  
}

//	****************************************************************************
//	****************************************************************************
void UpdateTimer (void)
{
   char i;

   for(i=0;i<TMR_NUMBER;i++)
   {
      if(Timer[i] > (_TICK_DEC_TIMER-1))
      {
         Timer[i] -= _TICK_DEC_TIMER;  
      }
   }

   // check TmrSecond variable
   if (TmrSecond == 0)
   {
      // update TmrError
      TmrError++;
   }
   else
   {
      // update TmrSecond
      TmrSecond -= _TICK_DEC_TIMER;
   }
   
}

//	****************************************************************************
//	****************************************************************************
unsigned char ControlloTimer0 (char i)
{
   if (Timer[i] == 0)
   {
      return i;
   }
   else
   {
      return 0xFF;
   }

}
